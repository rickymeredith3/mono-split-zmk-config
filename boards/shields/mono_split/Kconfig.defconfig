## boards/shields/mono_split/Kconfig.defconfig
```kconfig
if SHIELD_MONO_SPLIT

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Ricky's Board"

endif
```
